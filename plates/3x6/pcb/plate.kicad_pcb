File: plates/3x6/pcb/plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 274.2 x 94.7 mm, 0 parts

Commit message: update plate
Other:
- board size 274.2 x 94.7 mm -> 273.7 x 94.8 mm
